# Keil uVision project parking-control.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: parking-control
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c font_8x16.c font_12x24.c font_16x32.c glcd.c
  group ::Device
    RTE/Device/LPC4088FET208/: RTE_Device.h startup_LPC407x_8x_177x_8x.s system_LPC407x_8x_177x_8x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
